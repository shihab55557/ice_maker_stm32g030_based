# Keil uVision project ice_maker.uvprojx, settings and files
target Target 1 (6210000::V6.21::ARMCLANG)
  device: STM32G030F6Px STMicroelectronics
  pack: Keil.STM32G0xx_DFP.1.5.0
  cpu: IRAM(0x20000000,0x00002000) IROM(0x08000000,0x00008000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: ice_maker
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Source Group 1
    ./: main.c adc.h serial.c serial.h timer.c timer.h icemaker.c icemaker.h instruction.txt ntc.h adc.c ntc.c
software components: CMSIS:CORE 6.0.0, Device:Startup 1.4.2
